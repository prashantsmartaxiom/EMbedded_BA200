# IAR project APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32H487ZE Nations N32H487ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H487; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.IExtraOptions: -DMPQ7210_NEW=0
  ICCARM.CCIncludePath2: Include; Libraries\CMSIS\N32H48x\inc; Libraries\Common\inc; Libraries\Middleware\Components\inc; Libraries\Middleware\FreeRTOS\include; Libraries\Middleware\FreeRTOS\portable\IAR\ARM_CM4F; Libraries\Middleware\LWIP\include; Libraries\Middleware\LWIP\include\lwip; Libraries\Middleware\LWIP\include\lwip\apps; Libraries\Middleware\LWIP\include\lwip\priv; Libraries\Middleware\LWIP\include\lwip\prot; Libraries\Middleware\LWIP\include\netif; Libraries\Middleware\LWIP\bsp; Libraries\Middleware\LWIP\bsp\arch; Libraries\Middleware\MQTT\inc; Libraries\N32H48x_HAL_API\inc; Libraries\N32H48x_Register_Driver\inc; Libraries\N32H48x_Standard_Peripheral_Driver\inc; $TOOLKIT_DIR$\CMSIS\Core\Include; Libraries\Middleware\CJSON\inc; Libraries\BootLib\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Libraries\Middleware\FreeRTOS\include
  OBJCOPY.OOCOutputFile: APP_BA200_Debug-v1.0.0.1.hex
  ILINK.IlinkOutputFile: APP.out
  ILINK.IlinkIcfFile: N32H487xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Include
    Include/: adc_routine.h app_manager.h boot_process.h device_polling.h gui_box_control.h hmi_panel.h interrupt.h io.h led.h main.h messages.h mqtt_client.h parse.h peripheral_setup.h pir_task.h shade.h
  group Libraries
    Libraries/: startup_n32h487_EWARM.s
  group Libraries/BootLib/inc
    Libraries/BootLib/inc/: Boot_Internal_Task.h Data_Structure.h
  group Libraries/BootLib/src
    Libraries/BootLib/src/: CalcuCRC16.c CalcuCRC32.c
  group Libraries/CMSIS/inc
    Libraries/CMSIS/N32H48x/inc/: n32h47x_48x.h n32h47x_48x_conf.h system_n32h47x_48x.h
  group Libraries/CMSIS/src
    Libraries/CMSIS/N32H48x/src/: system_n32h47x_48x.c
  group Libraries/Common/inc
    Libraries/Common/inc/: base_type.h circular_buffer.h
  group Libraries/Common/src
    Libraries/Common/src/: circular_buffer.c
  group Libraries/Middleware/CJSON/inc
    Libraries/Middleware/CJSON/inc/: bsp_cjson.h cJSON.h
  group Libraries/Middleware/CJSON/src
    Libraries/Middleware/CJSON/src/: bsp_cjson.c cJSON.c
  group Libraries/Middleware/Components/inc
    Libraries/Middleware/Components/inc/: air_driver.h gui_driver.h hmi_driver.h i2c_device_driver.h light_driver.h meter_driver.h mpq7210_driver.h shade_driver.h
  group Libraries/Middleware/Components/src
    Libraries/Middleware/Components/src/: air_driver.c gui_driver.c hmi_driver.c i2c_device_driver.c light_driver.c meter_driver.c mpq7210_driver.c shade_driver.c
  group Libraries/Middleware/FreeRTOS
    Libraries/Middleware/FreeRTOS/portable/IAR/ARM_CM4F/: portasm.s
  group Libraries/Middleware/FreeRTOS/inc
    Libraries/Middleware/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    Libraries/Middleware/FreeRTOS/portable/IAR/ARM_CM4F/: portmacro.h
  group Libraries/Middleware/FreeRTOS/src
    Libraries/Middleware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Libraries/Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    Libraries/Middleware/FreeRTOS/portable/IAR/ARM_CM4F/: port.c
  group Libraries/Middleware/LWIP/inc/apps
    Libraries/Middleware/LWIP/include/lwip/apps/: altcp_proxyconnect.h altcp_tls_mbedtls_opts.h fs.h http_client.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_domain.h mdns_opts.h mdns_out.h mdns_priv.h mqtt.h mqtt_opts.h mqtt_priv.h netbiosns.h netbiosns_opts.h smtp.h smtp_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_client.h tftp_common.h tftp_opts.h tftp_server.h
  group Libraries/Middleware/LWIP/inc/bsp
    Libraries/Middleware/LWIP/bsp/: bsp_eth.h delay.h ethernetif.h log.h lwipopts.h
  group Libraries/Middleware/LWIP/inc/lwip
    Libraries/Middleware/LWIP/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group Libraries/Middleware/LWIP/inc/netif
    Libraries/Middleware/LWIP/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group Libraries/Middleware/LWIP/inc/priv
    Libraries/Middleware/LWIP/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group Libraries/Middleware/LWIP/inc/prot
    Libraries/Middleware/LWIP/include/lwip/prot/: acd.h autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Libraries/Middleware/LWIP/src/api
    Libraries/Middleware/LWIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Libraries/Middleware/LWIP/src/bsp
    Libraries/Middleware/LWIP/bsp/: bsp_eth.c delay.c ethernetif.c log.c sys_arch.c
  group Libraries/Middleware/LWIP/src/core
    Libraries/Middleware/LWIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Libraries/Middleware/LWIP/src/ipv4
    Libraries/Middleware/LWIP/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Libraries/Middleware/LWIP/src/mqtt
    Libraries/Middleware/LWIP/apps/mqtt/: mqtt.c
  group Libraries/Middleware/LWIP/src/netif
    Libraries/Middleware/LWIP/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group Libraries/Middleware/MQTT/inc
    Libraries/Middleware/MQTT/inc/: MQTTConnect.h MQTTFormat.h MQTTPacket.h MQTTPublish.h MQTTSubscribe.h MQTTUnsubscribe.h StackTrace.h transport.h
  group Libraries/Middleware/MQTT/src
    Libraries/Middleware/MQTT/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group Libraries/N32H48x_HAL_API/inc
    Libraries/N32H48x_HAL_API/inc/: n32h48x_dma_driver.h n32h48x_i2c_driver.h n32h48x_spi_driver.h n32h48x_uart_driver.h
  group Libraries/N32H48x_HAL_API/src
    Libraries/N32H48x_HAL_API/src/: n32h48x_dma_driver.c n32h48x_i2c_driver.c n32h48x_spi_driver.c n32h48x_uart_driver.c
  group Libraries/N32H48x_Register_Driver/inc
    Source/: main.c
    Libraries/N32H48x_Register_Driver/inc/: n32h48x_register.h n32h48x_register_adc.h n32h48x_register_afio.h n32h48x_register_dma.h n32h48x_register_flash.h n32h48x_register_gpio.h n32h48x_register_i2c.h n32h48x_register_rcc.h n32h48x_register_spi.h n32h48x_register_usart.h
  group Libraries/N32H48x_Register_Driver/src
    Libraries/N32H48x_Register_Driver/src/: n32h48x_register.c
  group Libraries/N32H48x_Standard_Peripheral_Driver/inc
    Libraries/N32H48x_Standard_Peripheral_Driver/inc/: misc.h n32h47x_48x_adc.h n32h47x_48x_comp.h n32h47x_48x_cordic.h n32h47x_48x_crc.h n32h47x_48x_dac.h n32h47x_48x_dbg.h n32h47x_48x_dma.h n32h47x_48x_dvp.h n32h47x_48x_eth.h n32h47x_48x_exti.h n32h47x_48x_fdcan.h n32h47x_48x_femc.h n32h47x_48x_flash.h n32h47x_48x_fmac.h n32h47x_48x_gpio.h n32h47x_48x_i2c.h n32h47x_48x_iwdg.h n32h47x_48x_lptim.h n32h47x_48x_pga.h n32h47x_48x_pwr.h n32h47x_48x_rcc.h n32h47x_48x_rtc.h n32h47x_48x_sdio.h n32h47x_48x_shrtim.h n32h47x_48x_spi.h n32h47x_48x_tim.h n32h47x_48x_usart.h n32h47x_48x_vrefbuf.h n32h47x_48x_wwdg.h n32h47x_48x_xspi.h
  group Libraries/N32H48x_Standard_Peripheral_Driver/src
    Libraries/N32H48x_Standard_Peripheral_Driver/src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group Source
    Source/: adc_routine.c app_manager.c boot_process.c device_polling.c gui_box_control.c hmi_panel.c interrupt.c led.c mqtt_client.c parse.c peripheral_setup.c pir_task.c shade.c
    ./: N32H487xE.icf
